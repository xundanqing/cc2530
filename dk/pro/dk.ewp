# IAR project dk.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\src\app; ..\src\hal; ..\src\drv; ..\src\protocal
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCIncludePath2: ..\src\app; ..\src\drv; ..\src\hal
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
  group app
    ../src/app/: dk_main.c dk_rfvp.c dk_rfvp.h
  group drv
    ../src/drv/: dk_config.h dk_key.c dk_key.h dk_led.c dk_led.h dk_rf_drv.c dk_uart_drv.c dk_uart_drv.h
  group hal
    ../src/hal/: dk_adc.c dk_adc.h dk_dma.h dk_flash.c dk_flash.h dk_gpio.c dk_gpio.h dk_rf.c dk_rf.h dk_system.c dk_system.h dk_timer.c dk_timer.h dk_uart.c dk_uart.h
  group protocal
    ../src/protocal/: __generated__ir.h __generated__laser.h __generated__zigbee.h __generated_handlers__zigbee.h dkTypes.c dkTypes.h
